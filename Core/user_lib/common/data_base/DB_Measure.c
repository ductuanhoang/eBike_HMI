/*
 * DB_Measure.c
 *
 *  Created on: Jun 10, 2020
 *      Author: Yolo
 */

/***********************************************************************************************************************
* History      : DD.MM.YYYY Version    Description
*              : 22.03.2020   1.00     First Release
*              : DD.MM.YYYY   x.00     First Release
*              : DD.MM.YYYY   x.00     First Release
***********************************************************************************************************************/

/***********************************************************************************************************************
* Pragma directive
***********************************************************************************************************************/

/***********************************************************************************************************************
* Includes <System Includes>
***********************************************************************************************************************/
#include "DB_Measure.h"
#include <math.h>
/***********************************************************************************************************************
* Macro definitions
***********************************************************************************************************************/

/***********************************************************************************************************************
* Typedef definitions
***********************************************************************************************************************/

/***********************************************************************************************************************
* Private global variables and functions
***********************************************************************************************************************/

/***********************************************************************************************************************
* Exported global variables and functions (to be accessed by other files)
***********************************************************************************************************************/
float DB_Measure[E_end_off_table_measure];

/***********************************************************************************************************************
* Imported global variables and functions (from other files)
***********************************************************************************************************************/

/***********************************************************************************************************************
* Function Name: void DB_Measure_init( void )
* Description  :
* Arguments    : none
* Return Value : none
***********************************************************************************************************************/
void DB_Measure_init( void )
{
	for (int var = 0; var < E_end_off_table_measure; var++)
	{
		DB_Measure[var] = 0;
	}
}
/***********************************************************************************************************************
* Function Name: DB_Measure_Write
* Description  :
* Arguments    : e_DB_Measure id, int16_t value
* Return Value : none
***********************************************************************************************************************/
void DB_Measure_Write(e_DB_Measure id, float value)
{
	if( id < E_end_off_table_measure)
	{
		DB_Measure[id] = (int16_t)(value * 10) / 10.0;
	}

}

float DB_Measure_Read(e_DB_Measure Id)
{
	float measure_data;
	if( Id < E_end_off_table_measure)
		measure_data = DB_Measure[Id];
	else measure_data = 0;

    return measure_data;
}

/***********************************************************************************************************************
* static functions
***********************************************************************************************************************/

/***********************************************************************************************************************
* End of file
***********************************************************************************************************************/

