/*
 * DB_Err.c
 *
 *  Created on: Jun 10, 2020
 *      Author: Yolo
 */


/***********************************************************************************************************************
* History      : DD.MM.YYYY Version    Description
*              : 22.03.2020   1.00     First Release
*              : DD.MM.YYYY   x.00     First Release
*              : DD.MM.YYYY   x.00     First Release
***********************************************************************************************************************/

/***********************************************************************************************************************
* Pragma directive
***********************************************************************************************************************/

/***********************************************************************************************************************
* Includes <System Includes>
***********************************************************************************************************************/
#include "DB_Err.h"

/***********************************************************************************************************************
* Macro definitions
***********************************************************************************************************************/

/***********************************************************************************************************************
* Typedef definitions
***********************************************************************************************************************/

/***********************************************************************************************************************
* Private global variables and functions
***********************************************************************************************************************/

/***********************************************************************************************************************
* Exported global variables and functions (to be accessed by other files)
***********************************************************************************************************************/
uint8_t DB_Err[E_end_off_table_err];
uint16_t DB_Err_Motor = 0;
uint16_t DB_Err_Refri = 0;

/***********************************************************************************************************************
* Imported global variables and functions (from other files)
***********************************************************************************************************************/

/***********************************************************************************************************************
* Function Name: DB_Err_init
* Description  :
* Arguments    : none
* Return Value : none
***********************************************************************************************************************/
void DB_Err_init( void )
{
	for (int i = 0; i < E_end_off_table_err; i++)
	{
		/* code */
		DB_Err[i] = 0;
	}
}
/***********************************************************************************************************************
* Function Name: DB_Err_Write
* Description  :
* Arguments    : none
* Return Value : none
***********************************************************************************************************************/
void DB_Err_Write( e_DB_Err id, uint8_t value)
{
	if ( id < E_end_off_table_err)
		DB_Err[id] = value;
}
/***********************************************************************************************************************
* Function Name: DB_Err_Read
* Description  :
* Arguments    : none
* Return Value : none
***********************************************************************************************************************/

uint8_t DB_Err_Read( e_DB_Err id)
{
	return DB_Err[id];
}

uint16_t DB_Err_Motor_Read(void)
{
	e_DB_Err i;
	for(i = ERR_MOTOR_OVERTEMPERATURE; i<= ERR_MOTOR_LOST_CONNECT;i++){
		DB_Err_Motor |= DB_Err[i] << i;
	}
	return DB_Err_Motor;
}




/***********************************************************************************************************************
* static functions
***********************************************************************************************************************/

/***********************************************************************************************************************
* End of file
***********************************************************************************************************************/
